DEPENDS += "gobject-introspection gobject-introspection-native qemu-native"
