DEPENDS:append = " gstreamer1.0"
PACKAGECONFIG:append = " gstreamer"
