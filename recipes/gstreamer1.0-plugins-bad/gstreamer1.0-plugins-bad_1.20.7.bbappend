FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-meta-qti-gst-Add-support-for-protected-content-caps-.patch"

