SRC_URI:remove = "git://salsa.debian.org/iso-codes-team/iso-codes.git;protocol=https;branch=main;"
SRC_URI:prepend = "${CLO_LE_GIT}/iso-codes.git;branch=caf_migration/iso-codes-team/main;protocol=https"
