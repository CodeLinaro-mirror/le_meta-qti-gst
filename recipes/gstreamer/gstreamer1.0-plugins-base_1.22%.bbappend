FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}/1.22:"

SRC_URI += "\
    file://0001-video-Add-support-for-NV12_Q08C-compressed-8-bit-for.patch \
"
