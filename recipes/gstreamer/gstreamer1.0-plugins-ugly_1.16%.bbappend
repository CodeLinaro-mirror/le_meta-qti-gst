PACKAGECONFIG:remove = "mpeg2dec"

