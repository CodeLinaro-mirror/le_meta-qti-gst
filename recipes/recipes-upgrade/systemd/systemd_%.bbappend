FILESEXTRAPATHS_prepend := "${THISDIR}:"

SRC_URI += "file://0001-run-the-rsync-command-only-if-rsync-is-found.patch"